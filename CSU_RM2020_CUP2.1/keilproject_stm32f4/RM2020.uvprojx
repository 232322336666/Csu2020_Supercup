# Keil uVision project RM2020.uvprojx, settings and files
target RM2020 (ARM-ADS)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x00100000) IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RM2020 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40XX,USE_STDPERIPH_DRIVER,MPU6050,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c misc: --gnu -Dlittle_endian
  c include: ..\MAKOS;..\MAKOS\includes;..\MAKOS\kernel;..\MAKOS\migration;..\STM32F4;..\STM32F4\inc;..\system;..\user\device;..\user;..\user\device\mpu;..\user\driver;..\user\user_other;..\user\user_app;..\STM32F4\DSP_LIB\Include;..\user\base_app
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group main
    ../user/: main.c
  group user/app
    ../user/user_app/: task_init.c task_vision.c task_holder.c task_chassis.c task_INA226.c task_pwm_pid.c
    ../user/device/: can.c
  group user/other
    ../user/user_other/: communicate.c holder_pid.c pid.c user_can.c user_usart.c UI.c pos_ctrl.c iic_soft.c
  group base/app
    ../user/base_app/: task_judge.c task_remote.c task_mems.c task_nimin.c task_led.c task_UI.c task_Ano.c
  group device
    ../user/device/: flash_data.c keyboard.c uart_dma.c dbus.c motor.c timer.c led.c oled.c PWM.c spi.c usart.c i2c.c
  group driver
    ../user/driver/: communicate_nimin.c irq_dead_check.c judgement_info.c stm32_flash.c nimin_info.c data_fifo.c mak_pid.c protocol.c UI_lib.c
  group MAKOS
    ../MAKOS/migration/: makos_pendsv.c makos_critical.c makos_tick.c
    ../MAKOS/includes/: makos_doublelist.c makos_F2S.c
    ../MAKOS/kernel/: makos_memory.c makos_mutex.c makos_semaphore.c makos_pipe.c makos_task.c makos_system.c makos_message.c makos_schedule.c makos_tick_handle.c makos_dnode_queue.c makos_print.c makos_idle.c makos_resolver.c makos_irq_handle.c makos_record.c mak_print.c
  group STM32F4
    ../STM32F4/: stm32f4xx_it.c system_stm32f4xx.c startup_stm32f40xx.s
    ../STM32F4/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
    ../STM32F4/DSP_LIB/: arm_cortexM4lf_math.lib
  group DOC
    ../DOC/: 裁判系统API.txt
    ../../: readme.txt ANO.txt
